Commit message: control modeと初期姿勢検証

File: assets/ur3e/ur3e_maniskill.urdf (robot description, URDF)
Before this commit: robot ur3e, 13 links, 12 joints
Links:
- link tool0: geometry visual sphere radius=0.012
